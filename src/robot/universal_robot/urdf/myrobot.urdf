Commit message: Primer commit

File: src/robot/universal_robot/urdf/myrobot.urdf (robot description, URDF)
Before this commit: robot myrobot, 10 links, 9 joints
Links:
- link base_link: mass 414.0 -> 36.629
